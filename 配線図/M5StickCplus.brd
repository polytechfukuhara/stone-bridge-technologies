# Repository polytechfukuhara/stone-bridge-technologies

## EAGLE design 配線図/M5StickCplus.brd

Parts:
U$1: FT1117M
U$2: M5STICKCPLUS; M5STICK
U$3: TECONNECTIVITY1005447-1

Connections:
unnamed: U$1.GND, U$2.GND1, U$3.P$1 (GND)
unnamed: U$1.5V, U$2.VOUT (V OUT), U$3.P$2 (VCC)
unnamed: U$1.NC, U$2.G33, U$3.P$4 (SIG)
unnamed: U$1.SIGNAL, U$2.G32, U$3.P$3 (NC)

Board: 2 copper layers, 60.6 x 55.9 mm, 3 parts (0 on the bottom side), 4 nets.

## EAGLE design 配線図/M5StickCplusbattery.brd

Parts:
CR123A1, CR123A2: AAA; 12BH412
U$1: M5STICKCPLUS; M5STICK

Connections:
unnamed: CR123A1.+, CR123A2.-
unnamed: CR123A2.+, U$1.GND
unnamed: CR123A1.-, U$1.5VIN (5V ←)

Board: 2 copper layers, 136.8 x 38.1 mm, 3 parts (0 on the bottom side), 3 nets.

## EAGLE design 配線図/M5StickSub.brd

Parts:
G1, G2: CR2032V
U$1: M5STICKCPLUS; M5STICK

Connections:
unnamed: G1.+, G2.-
unnamed: G2.+, U$1.5VIN (5V ←)
unnamed: G1.-, U$1.5VOUT (5V →)

Notes on the sheet:
電池ホルダー
M5StickC Plus
スマートキー側

Board: 2 copper layers, 68.2 x 82.5 mm, 3 parts (0 on the bottom side), 3 nets.

## Commit log

2023-03-14 test
2023-03-14 3月14日最終（エラー：ボードM5Stick-C-Plusに対するコンパイル時にエラーが発生しました。）
2023-03-15 エラーなし
2023-03-15 コメントアウトメインサブ共//timerSub.onTimer(); //180秒カウント＆スリープ
2023-03-15 //180秒カウント＆スリープ(コメントアウト中)
2023-03-17 Lineの通知（Fake）を作成
2023-03-17 LineNotufy通知をMainに追加（動かない）
2023-03-17 Timerのテストコードを追加
2023-03-17 Timer_test2を追加
2023-03-17 17日最新
2023-03-27 20230323フォルダ追加（二宮作業追加分）
2023-03-29 印刷用にコメント追加 20230323 フォルダ分
